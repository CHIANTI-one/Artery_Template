# Keil uVision project F421C8T7.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: -AT32F421C8T7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.8
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: F421C8T7
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\USER;.\CMSIS;.\Library\inc;.\Library\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ./USER/: at32f421_clock.c at32f421_int.c main.c
  group CMSIS
    ./CMSIS/: startup_at32f421.s system_at32f421.c
  group DRIVE
    ./Library/src/: at32f421_adc.c at32f421_cmp.c at32f421_crc.c at32f421_debug.c at32f421_dma.c at32f421_ertc.c at32f421_exint.c at32f421_flash.c at32f421_gpio.c at32f421_i2c.c at32f421_pwc.c at32f421_scfg.c at32f421_spi.c at32f421_tmr.c at32f421_usart.c at32f421_wdt.c at32f421_wwdt.c
  group FIRMWARE
    ./Library/src/: at32f421_crm.c at32f421_misc.c
